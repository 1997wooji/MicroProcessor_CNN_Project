# Keil uVision project p4.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: p4
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\p4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Objects\p4.sct
  group source
    ./: main.c grayscale.s convolution.s maxpoolingassem.s relocation.s
  group header
    ./: base.h
  group object
    ./: serial.o startup.o
